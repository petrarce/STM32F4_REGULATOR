# Keil uVision project PWMandOnboardLEDS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: PWMandOnboardLEDS
  c flags: Optim=1 uC99=1
  c include: .\CMSIS_ORIGINAL\Device\ST\STM32F4xx\Include;.\CMSIS_ORIGINAL\Device\ST\STM32F4xx\Source;.\MyCode;.\STM32F4xx_StdPeriph_Driver_ORIGINAL\inc;.\STM32F4xx_StdPeriph_Driver_ORIGINAL\src;.\STM32F4xx_StdPeriph_Driver_ORIGINAL;.\freertos\include;.\TEST
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f40_41xxx.s
  group MyCode
    ./MyCode/: mcuInit.c alldefines.h main.c Functions.c FlowFunctions.c
  group CMSIS_ORIGIN
    ./CMSIS_ORIGINAL/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StdPeriph_ORIGIN
    ./STM32F4xx_StdPeriph_Driver_ORIGINAL/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./STM32F4xx_StdPeriph_Driver_ORIGINAL/: stm32f4xx_conf.h
  group freertos
    ./freertos/: croutine.c heap_3.c list.c port.c queue.c tasks.c timers.c FreeRTOSConfig.h
  group TEST
    ./TEST/: TEST.c
